** sch_path: tbs/post_PEX_13_14_15.sch
**.subckt post_PEX_13_14_15
vA0 A0 GND 3.3
vA1 A1 GND 3.3
vA2 A2 GND 3.3
vA3 A3 GND 3.3
vA4 A4 GND 3.3
vA5 A5 GND 3.3
vA6 A6 GND 3.3
vA7 A7 GND 3.3
vA8 A8 GND 3.3
vA9 A9 GND 3.3
vA10 A10 GND 3.3
vA11 A11 GND 3.3
vA12 A12 GND 3.3
vA13 A13 GND 3.3
vA14 A14 GND 3.3
vA15 A15 GND 3.3
vSh1 Sh1 GND 3.3
vSh2 Sh2 GND 3.3
vSh4 Sh4 GND 3.3
vSh8 Sh8 GND 3.3
V2 VDD GND 3.3
vSh1b Sh1b GND 3.3
vSh2b Sh2b GND 3.3
vSh4b Sh4b GND 3.3
vSh8b Sh8b GND 3.3
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical



.control
let vlow = 0
let vhigh = 3.3
* A = 1010101010101010 = 43690
alter VA15 = $&vhigh
alter VA14 = $&vlow
alter VA13 = $&vhigh
alter VA12 = $&vlow
alter VA11 = $&vhigh
alter VA10 = $&vlow
alter VA9  = $&vhigh
alter VA8  = $&vlow
alter VA7  = $&vhigh
alter VA6  = $&vlow
alter VA5  = $&vhigh
alter VA4  = $&vlow
alter VA3  = $&vhigh
alter VA2  = $&vlow
alter VA1  = $&vhigh
alter VA0  = $&vlow


* --- SHIFT 1 (0001) ---
alter vSh1 = $&vhigh
alter vSh2 = $&vlow
alter vSh4 = $&vlow
alter vSh8 = $&vlow

alter vSh1b = $&vlow
alter vSh2b = $&vhigh
alter vSh4b = $&vhigh
alter vSh8b = $&vhigh
tran 10n 1u

meas tran v14_0  find v(OUT0)  at=30n
meas tran v14_1  find v(OUT1)  at=30n
meas tran v14_2  find v(OUT2)  at=30n
meas tran v14_3  find v(OUT3)  at=30n
meas tran v14_4  find v(OUT4)  at=30n
meas tran v14_5  find v(OUT5)  at=30n
meas tran v14_6  find v(OUT6)  at=30n
meas tran v14_7  find v(OUT7)  at=30n
meas tran v14_8  find v(OUT8)  at=30n
meas tran v14_9  find v(OUT9)  at=30n
meas tran v14_10 find v(OUT10) at=30n
meas tran v14_11 find v(OUT11) at=30n
meas tran v14_12 find v(OUT12) at=30n
meas tran v14_13 find v(OUT13) at=30n
meas tran v14_14 find v(OUT14) at=30n
meas tran v14_15 find v(OUT15) at=30n

let res14 = 0
if v14_0 > 1.6
  let res14 = res14 + 1
end
if v14_1 > 1.6
  let res14 = res14 + 2
end
if v14_2 > 1.6
  let res14 = res14 + 4
end
if v14_3 > 1.6
  let res14 = res14 + 8
end
if v14_4 > 1.6
  let res14 = res14 + 16
end
if v14_5 > 1.6
  let res14 = res14 + 32
end
if v14_6 > 1.6
  let res14 = res14 + 64
end
if v14_7 > 1.6
  let res14 = res14 + 128
end
if v14_8 > 1.6
  let res14 = res14 + 256
end
if v14_9 > 1.6
  let res14 = res14 + 512
end
if v14_10 > 1.6
  let res14 = res14 + 1024
end
if v14_11 > 1.6
  let res14 = res14 + 2048
end
if v14_12 > 1.6
  let res14 = res14 + 4096
end
if v14_13 > 1.6
  let res14 = res14 + 8192
end
if v14_14 > 1.6
  let res14 = res14 + 16384
end
if v14_15 > 1.6
  let res14 = res14 + 32768
end
echo 14_gives_32768
print res14

.endc




.subckt SHIFT OUT1 OUT2 OUT3 OUT4 OUT5 OUT6 OUT7 OUT8 OUT9 OUT10 OUT11 OUT12 OUT0  OUT13 OUT14 OUT15
+ GND A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A0 A13 A14 A15
X0 m2_n7_n8438# Sh1 A12.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X1 OUT15.t1 Sh8 a_2735_n10830# GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X2 a_484_n9954# Sh2 m2_n7_n9922# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X3 GND.t11 Sh8b OUT7.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u l=0.28u
X4 GND.t10 Sh8b OUT6.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u l=0.28u
X5 A5.t1 Sh1b m2_n7_n3986# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u l=0.28u
X6 OUT4.t1 Sh8 a_2735_n8210.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X7 a_484_n5502# Sh2 m2_n7_n5470# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X8 OUT7.t1 Sh8 a_2735_n4931.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X9 m2_n7_n1018# Sh1 A2.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X10 a_2735_n7476.t1 Sh8b OUT11.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X11 A0.t1 Sh1b m2_n7_n276# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u l=0.28u
X12 a_484_n7728# Sh2 m2_n7_n7696# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u w=0.5u
+ l=0.28u
X13 m2_n7_n3244# Sh1 A5.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X14 A8.t1 Sh1b m2_n7_n6212# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X15 GND.t15 Sh4b a_2735_n7476.t2 GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X16 m2_n7_n6954# Sh2b a_484_n8470# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X17 OUT9.t1 Sh8 a_2735_n6405.t2 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X18 OUT8.t1 Sh8 a_2735_n5672.t2 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X19 OUT6.t1 Sh8 a_2735_n9685.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X20 a_484_434# Sh4b a_2735_n8210.t2 GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X21 m2_n7_n10664# Sh1 A15.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X22 m2_n7_466# Sh1 A0.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X23 A9.t1 Sh1b m2_n7_n6954# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X24 OUT11.t1 Sh8 a_2735_n7880# GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X25 a_2735_n8951.t1 Sh8b OUT13.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X26 a_2735_227.t0 Sh4 a_484_434# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X27 m2_n7_n6212# Sh1 A9.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X28 a_484_n1050# Sh4b a_2735_n9685.t2 GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X29 a_484_n8470# Sh2 m2_n7_n8438# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X30 OUT1.t1 Sh8 a_2735_n506.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X31 a_2735_n7476.t0 Sh4 a_484_n1792# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u
+ w=0.5u l=0.28u
X32 m2_n7_n9180# Sh2b a_484_n10696# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X33 GND.t18 Sh2b a_484_n308# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X34 a_484_n7728# Sh4b a_2735_n10830# GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X35 a_2735_n8210.t0 Sh4 a_484_n2534# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u
+ w=0.5u l=0.28u
X36 m2_n7_n2502# Sh2b a_484_n4018# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X37 A12.t1 Sh1b m2_n7_n9180# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X38 a_484_n1792# Sh4b a_2735_n4931.t2 GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X39 a_484_n3276# Sh4b a_2735_n6405.t1 GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X40 a_484_n2534# Sh4b a_2735_n5672.t1 GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X41 a_484_n1050# Sh2 m2_n7_n1018# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X42 A2.t1 Sh1b m2_n7_n1760# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X43 a_2735_n8951.t0 Sh4 a_484_n3276# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u
+ w=0.5u l=0.28u
X44 A13.t1 Sh1b m2_n7_n9922# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X45 m2_n7_n4728# Sh2b a_484_n6244# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X46 a_2735_n6735.t1 Sh8b OUT10.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X47 a_484_n4760# Sh4b a_2735_n7880# GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X48 a_484_n4018# Sh4b a_2735_n7147.t1 GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X49 a_484_n3276# Sh2 m2_n7_n3244# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u w=0.5u
+ l=0.28u
X50 m2_n7_n9180# Sh1 A13.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X51 GND.t9 Sh8b OUT3.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u l=0.28u
X52 a_2735_n4931.t0 Sh4 a_484_n4760# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u
+ w=0.5u l=0.28u
X53 GND.t17 Sh2b a_484_434# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X54 a_2735_n5672.t0 Sh4 a_484_n5502# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u
+ w=0.5u l=0.28u
X55 a_2735_n6405.t0 Sh4 a_484_n6244# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u
+ w=0.5u l=0.28u
X56 GND.t14 Sh4b a_2735_n506.t2 GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X57 m2_n7_n5470# Sh2b a_484_n6986# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X58 m2_n7_n1760# Sh1 A3.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X59 OUT0.t1 Sh8 a_2735_227.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X60 GND.t8 Sh8b OUT2.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u l=0.28u
X61 OUT10.t1 Sh8 a_2735_n7147.t2 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X62 a_484_n6244# Sh2 m2_n7_n6212# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u w=0.5u
+ l=0.28u
X63 a_2735_n8210.t1 Sh8b OUT12.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X64 OUT3.t1 Sh8 a_2735_n7476.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X65 GND.t7 Sh8b OUT5.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u l=0.28u
X66 a_484_n5502# Sh4b a_2735_n8622# GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X67 a_484_n6244# Sh4b a_2735_n9355# GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X68 A1.t1 Sh1b m2_n7_n1018# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X69 A6.t1 Sh1b m2_n7_n4728# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X70 m2_n7_n7696# Sh2b a_484_n9212# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X71 m2_n7_n3986# Sh1 A6.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X72 m2_n7_n276# Sh1 A1.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X73 a_2735_n6735.t0 Sh4 a_484_n1050# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u
+ w=0.5u l=0.28u
X74 m2_n7_n276# Sh2b a_484_n1792# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X75 A10.t1 Sh1b m2_n7_n7696# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X76 a_2735_n9355# Sh4 a_484_n9212# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X77 a_2735_n8622# Sh4 a_484_n8470# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X78 m2_n7_n8438# Sh2b a_484_n9954# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X79 m2_n7_n4728# Sh1 A7.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u l=0.28u
X80 a_484_n9212# Sh2 m2_n7_n9180# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u w=0.5u
+ l=0.28u
X81 GND.t2 Sh1b m2_n7_466# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u l=0.28u
X82 OUT13.t1 Sh8 a_2735_n9355# GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X83 m2_n7_466# Sh2b a_484_n1050# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X84 GND.t13 Sh4b a_2735_227.t2 GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X85 m2_n7_n9922# Sh1 A14.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X86 a_484_n308# Sh2 m2_n7_n276# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u w=0.5u
+ l=0.28u
X87 a_484_n10696# Sh2 m2_n7_n10664# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u
+ w=0.5u l=0.28u
X88 a_484_n1792# Sh2 m2_n7_n1760# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u w=0.5u
+ l=0.28u
X89 m2_n7_n6954# Sh1 A10.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X90 a_2735_n10830# Sh4 a_484_n10696# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u
+ w=0.5u l=0.28u
X91 a_2735_n9685.t0 Sh4 a_484_n4018# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u
+ w=0.5u l=0.28u
X92 A3.t1 Sh1b m2_n7_n2502# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X93 m2_n7_n3244# Sh2b a_484_n4760# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X94 GND.t6 Sh8b OUT4.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u l=0.28u
X95 a_1337_n9945# Sh4 a_484_n9954# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X96 a_484_n4018# Sh2 m2_n7_n3986# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X97 OUT2.t1 Sh8 a_2735_n6735.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X98 a_484_n6986# Sh4b a_1337_n9945# GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X99 a_2735_n7880# Sh4 a_484_n7728# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X100 m2_n7_n2502# Sh1 A4.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X101 m2_n7_n6212# Sh2b a_484_n7728# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X102 a_484_n4760# Sh2 m2_n7_n4728# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.355p ps=2.42u w=0.5u
+ l=0.28u
X103 A4.t1 Sh1b m2_n7_n3244# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X104 a_2735_n9685.t1 Sh8b OUT14.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X105 a_2735_n506.t1 Sh8b OUT9.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X106 a_2735_227.t1 Sh8b OUT8.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X107 a_2735_n7147.t0 Sh4 a_484_n6986# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u
+ w=0.5u l=0.28u
X108 a_2735_n506.t0 Sh4 a_484_n308# GND.t1 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u
+ w=0.5u l=0.28u
X109 GND.t5 Sh8b OUT0.t0 GND.t3 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u l=0.28u
X110 A7.t1 Sh1b m2_n7_n5470# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X111 A14.t1 Sh1b m2_n7_n10664# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X112 OUT12.t1 Sh8 a_2735_n8622# GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X113 OUT5.t1 Sh8 a_2735_n8951.t3 GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3575p ps=2.43u w=0.5u
+ l=0.28u
X114 a_484_n6986# Sh2 m2_n7_n6954# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u
+ w=0.5u l=0.28u
X115 GND.t4 Sh8b OUT1.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u l=0.28u
X116 OUT14.t1 Sh8 a_1337_n9945# GND.t3 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X117 m2_n7_n1018# Sh2b a_484_n2534# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X118 m2_n7_n5470# Sh1 A8.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X119 m2_n7_n7696# Sh1 A11.t0 GND.t0 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
X120 A11.t1 Sh1b m2_n7_n8438# GND.t0 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X121 a_2735_n4931.t1 Sh8b OUT15.t0 GND.t3 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X122 a_484_n308# Sh4b a_2735_n8951.t2 GND.t1 nfet_03v3 ad=0.27p pd=2.08u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X123 a_484_n2534# Sh2 m2_n7_n2502# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u
+ w=0.5u l=0.28u
X124 m2_n7_n1760# Sh2b a_484_n3276# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X125 GND.t12 Sh4b a_2735_n6735.t2 GND.t1 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u w=0.5u
+ l=0.28u
X126 m2_n7_n3986# Sh2b a_484_n5502# GND.t16 nfet_03v3 ad=0.2625p pd=2.05u as=0.18625p ps=1.245u
+ w=0.5u l=0.28u
X127 a_484_434# Sh2 m2_n7_466# GND.t16 nfet_03v3 ad=0.18625p pd=1.245u as=0.3775p ps=2.51u w=0.5u
+ l=0.28u
R0 A12.n0 A12.t1 28.8939
R1 A12.n0 A12.t0 12.4115
R2 A12 A12.n0 0.017375
R3 GND.n6 GND.t1 379.423
R4 GND.n5 GND.t16 231.463
R5 GND.n4 GND.t0 157.617
R6 GND.n14 GND.t11 17.5102
R7 GND.n13 GND.t10 16.5156
R8 GND.n12 GND.t7 15.5288
R9 GND.n11 GND.t6 14.5341
R10 GND.n10 GND.t9 13.5473
R11 GND GND.t15 13.5304
R12 GND.n18 GND.t12 12.533
R13 GND.n9 GND.t8 12.533
R14 GND.n2 GND.t18 11.5669
R15 GND.n17 GND.t14 11.5658
R16 GND.n8 GND.t4 11.5658
R17 GND.n1 GND.t17 10.5665
R18 GND.n16 GND.t13 10.5665
R19 GND.n7 GND.t5 10.5665
R20 GND.n3 GND.t2 10.4956
R21 GND.n7 GND.n6 4.93648
R22 GND.n4 GND.n0 4.38983
R23 GND.n15 GND.n5 4.38567
R24 GND.t0 GND.n3 4.10278
R25 GND.n16 GND.n15 0.553625
R26 GND.n1 GND.n0 0.553625
R27 GND.n3 GND.n2 0.32944
R28 GND.n15 GND.n14 0.13175
R29 GND.n19 GND.n0 0.129875
R30 GND.t1 GND.n5 0.109008
R31 GND.t16 GND.n4 0.108991
R32 GND.n6 GND.t3 0.108956
R33 GND.n2 GND.n1 0.107375
R34 GND.n17 GND.n16 0.107375
R35 GND.n8 GND.n7 0.107375
R36 GND.n18 GND.n17 0.1055
R37 GND.n14 GND.n13 0.1055
R38 GND.n13 GND.n12 0.1055
R39 GND.n12 GND.n11 0.1055
R40 GND.n11 GND.n10 0.1055
R41 GND.n10 GND.n9 0.1055
R42 GND.n9 GND.n8 0.1055
R43 GND.n19 GND.n18 0.1055
R44 GND GND.n19 0.017375
R45 OUT15 OUT15.n0 6.341
R46 OUT15.n0 OUT15.t0 4.7885
R47 OUT15.n0 OUT15.t1 4.5995
R48 OUT7 OUT7.n0 6.30838
R49 OUT7.n0 OUT7.t0 4.7885
R50 OUT7.n0 OUT7.t1 4.5995
R51 OUT6 OUT6.n0 6.30838
R52 OUT6.n0 OUT6.t0 4.7885
R53 OUT6.n0 OUT6.t1 4.5995
R54 A5.n0 A5.t1 28.8939
R55 A5.n0 A5.t0 12.4115
R56 A5 A5.n0 0.017375
R57 a_2735_n8210.n0 a_2735_n8210.t1 30.6913
R58 a_2735_n8210.n0 a_2735_n8210.t3 17.6776
R59 a_2735_n8210.n1 a_2735_n8210.n0 11.7511
R60 a_2735_n8210.n1 a_2735_n8210.t2 4.7885
R61 a_2735_n8210.t0 a_2735_n8210.n1 4.5995
R62 OUT4 OUT4.n0 6.31288
R63 OUT4.n0 OUT4.t0 4.7885
R64 OUT4.n0 OUT4.t1 4.5995
R65 a_2735_n4931.n0 a_2735_n4931.t1 31.1745
R66 a_2735_n4931.n0 a_2735_n4931.t3 18.1366
R67 a_2735_n4931.n1 a_2735_n4931.n0 11.2921
R68 a_2735_n4931.n1 a_2735_n4931.t2 4.7885
R69 a_2735_n4931.t0 a_2735_n4931.n1 4.5995
R70 A2.n0 A2.t1 28.8939
R71 A2.n0 A2.t0 12.4115
R72 A2 A2.n0 0.017375
R73 OUT11 OUT11.n0 6.32075
R74 OUT11.n0 OUT11.t0 4.7885
R75 OUT11.n0 OUT11.t1 4.5995
R76 a_2735_n7476.n0 a_2735_n7476.t1 30.5303
R77 a_2735_n7476.n0 a_2735_n7476.t3 17.5246
R78 a_2735_n7476.n1 a_2735_n7476.n0 11.9244
R79 a_2735_n7476.n1 a_2735_n7476.t2 4.7885
R80 a_2735_n7476.t0 a_2735_n7476.n1 4.5995
R81 A0.n0 A0.t1 28.8939
R82 A0.n0 A0.t0 12.4115
R83 A0 A0.n0 0.017375
R84 A8.n0 A8.t1 28.8939
R85 A8.n0 A8.t0 12.4115
R86 A8 A8.n0 0.017375
R87 a_2735_n6405.n0 a_2735_n6405.t2 29.4069
R88 a_2735_n6405.n0 a_2735_n6405.t1 4.7885
R89 a_2735_n6405.t0 a_2735_n6405.n0 4.5995
R90 OUT9 OUT9.n0 6.31062
R91 OUT9.n0 OUT9.t0 4.7885
R92 OUT9.n0 OUT9.t1 4.5995
R93 a_2735_n5672.n0 a_2735_n5672.t2 29.4069
R94 a_2735_n5672.n0 a_2735_n5672.t1 4.7885
R95 a_2735_n5672.t0 a_2735_n5672.n0 4.5995
R96 OUT8 OUT8.n0 6.3095
R97 OUT8.n0 OUT8.t0 4.7885
R98 OUT8.n0 OUT8.t1 4.5995
R99 a_2735_n9685.n0 a_2735_n9685.t1 31.0134
R100 a_2735_n9685.n0 a_2735_n9685.t3 17.9836
R101 a_2735_n9685.n1 a_2735_n9685.n0 11.4451
R102 a_2735_n9685.n1 a_2735_n9685.t2 4.7885
R103 a_2735_n9685.t0 a_2735_n9685.n1 4.5995
R104 A15 A15.t0 12.4284
R105 A9.n0 A9.t1 28.8939
R106 A9.n0 A9.t0 12.4115
R107 A9 A9.n0 0.017375
R108 OUT13 OUT13.n0 6.33088
R109 OUT13.n0 OUT13.t0 4.7885
R110 OUT13.n0 OUT13.t1 4.5995
R111 a_2735_n8951.n0 a_2735_n8951.t1 30.8524
R112 a_2735_n8951.n0 a_2735_n8951.t3 17.8306
R113 a_2735_n8951.n1 a_2735_n8951.n0 11.5981
R114 a_2735_n8951.n1 a_2735_n8951.t2 4.7885
R115 a_2735_n8951.t0 a_2735_n8951.n1 4.5995
R116 a_2735_227.n0 a_2735_227.t1 30.0425
R117 a_2735_227.n0 a_2735_227.t3 17.0645
R118 a_2735_227.n1 a_2735_227.n0 12.3845
R119 a_2735_227.n1 a_2735_227.t2 4.7885
R120 a_2735_227.t0 a_2735_227.n1 4.5995
R121 a_2735_n506.n0 a_2735_n506.t1 30.297
R122 a_2735_n506.n0 a_2735_n506.t3 17.2175
R123 a_2735_n506.n1 a_2735_n506.n0 12.2315
R124 a_2735_n506.n1 a_2735_n506.t2 4.7885
R125 a_2735_n506.t0 a_2735_n506.n1 4.5995
R126 OUT1 OUT1.n0 6.332
R127 OUT1.n0 OUT1.t0 4.7885
R128 OUT1.n0 OUT1.t1 4.5995
R129 A13.n0 A13.t1 28.8939
R130 A13.n0 A13.t0 12.4115
R131 A13 A13.n0 0.017375
R132 OUT10 OUT10.n0 6.31963
R133 OUT10.n0 OUT10.t0 4.7885
R134 OUT10.n0 OUT10.t1 4.5995
R135 a_2735_n6735.n0 a_2735_n6735.t1 30.3496
R136 a_2735_n6735.n0 a_2735_n6735.t3 17.3716
R137 a_2735_n6735.n1 a_2735_n6735.n0 12.0774
R138 a_2735_n6735.n1 a_2735_n6735.t2 4.7885
R139 a_2735_n6735.t0 a_2735_n6735.n1 4.5995
R140 a_2735_n7147.n0 a_2735_n7147.t2 29.4069
R141 a_2735_n7147.n0 a_2735_n7147.t1 4.7885
R142 a_2735_n7147.t0 a_2735_n7147.n0 4.5995
R143 OUT3 OUT3.n0 6.32187
R144 OUT3.n0 OUT3.t0 4.7885
R145 OUT3.n0 OUT3.t1 4.5995
R146 A3.n0 A3.t1 28.8939
R147 A3.n0 A3.t0 12.4115
R148 A3 A3.n0 0.017375
R149 OUT0 OUT0.n0 6.33312
R150 OUT0.n0 OUT0.t0 4.7885
R151 OUT0.n0 OUT0.t1 4.5995
R152 OUT2 OUT2.n0 6.323
R153 OUT2.n0 OUT2.t0 4.7885
R154 OUT2.n0 OUT2.t1 4.5995
R155 OUT12 OUT12.n0 6.32975
R156 OUT12.n0 OUT12.t0 4.7885
R157 OUT12.n0 OUT12.t1 4.5995
R158 OUT5 OUT5.n0 6.31175
R159 OUT5.n0 OUT5.t0 4.7885
R160 OUT5.n0 OUT5.t1 4.5995
R161 A1.n0 A1.t1 28.8939
R162 A1.n0 A1.t0 12.4115
R163 A1 A1.n0 0.017375
R164 A6.n0 A6.t1 28.8939
R165 A6.n0 A6.t0 12.4115
R166 A6 A6.n0 0.017375
R167 A10.n0 A10.t1 28.8939
R168 A10.n0 A10.t0 12.4115
R169 A10 A10.n0 0.017375
R170 A7.n0 A7.t1 28.8939
R171 A7.n0 A7.t0 12.4115
R172 A7 A7.n0 0.017375
R173 A14.n0 A14.t1 28.8939
R174 A14.n0 A14.t0 12.4115
R175 A14 A14.n0 0.017375
R176 A4.n0 A4.t1 28.8939
R177 A4.n0 A4.t0 12.4115
R178 A4 A4.n0 0.017375
R179 OUT14 OUT14.n0 6.33988
R180 OUT14.n0 OUT14.t0 4.7885
R181 OUT14.n0 OUT14.t1 4.5995
R182 A11.n0 A11.t1 28.8939
R183 A11.n0 A11.t0 12.4115
R184 A11 A11.n0 0.017375
C0 Sh2 A10 0
C1 Sh8 a_484_n6986# 0
C2 m2_n7_n8438# m2_n7_n6212# 0
C3 a_484_n9212# Sh1b 0.00117f
C4 Sh4b a_484_n9212# 0.02852f
C5 a_484_n9212# A14 0
C6 Sh1b m2_n7_n7696# 0.0106f
C7 Sh4b m2_n7_n7696# 0
C8 Sh4 m2_n7_n6212# 0
C9 Sh1 m2_n7_n6212# 0.03766f
C10 m2_n7_n3986# Sh1 0.02035f
C11 Sh2 m2_n7_n1018# 0.02076f
C12 Sh4 m2_n7_n3986# 0
C13 a_2735_n9355# m2_n7_n9922# 0
C14 Sh4b a_484_n1792# 0.07228f
C15 Sh4 OUT15 0
C16 m2_n7_n10664# A15 0.14359f
C17 Sh2 m2_n7_n9922# 0.01528f
C18 Sh8 a_484_n8470# 0
C19 A5 m2_n7_n3986# 0.04379f
C20 a_484_n9212# OUT14 0
C21 Sh4b A10 0
C22 Sh1b A10 0.05457f
C23 Sh2b a_484_n308# 0.01289f
C24 Sh8b Sh8 1.08425f
C25 A9 m2_n7_n6954# 0.04379f
C26 Sh1 A8 0.01558f
C27 m2_n7_n10664# m2_n7_n9922# 0.33786f
C28 Sh2 A4 0
C29 m2_n7_n1018# Sh1b 0.01328f
C30 Sh8 a_484_n3276# 0
C31 Sh4b m2_n7_n1018# 0
C32 A15 Sh1b 0.02539f
C33 a_484_n5502# OUT9 0
C34 A1 m2_n7_n1018# 0.04379f
C35 A14 A15 0.03878f
C36 A3 m2_n7_n1760# 0.14389f
C37 Sh4 a_484_n2534# 0.0264f
C38 Sh4b OUT10 0
C39 m2_n7_n9922# Sh1b 0.01328f
C40 Sh4b m2_n7_n9922# 0
C41 A14 m2_n7_n9922# 0.12891f
C42 Sh4 OUT8 0
C43 Sh2b m2_n7_n1760# 0.09596f
C44 Sh8 a_484_n4018# 0
C45 a_2735_n8622# a_484_n10696# 0
C46 A9 a_484_n6244# 0
C47 OUT15 a_2735_n10830# 0.05487f
C48 Sh4b A4 0
C49 A4 Sh1b 0.05457f
C50 A3 A2 0.04228f
C51 Sh4 a_484_n1050# 0.01656f
C52 a_484_n9212# m2_n7_n8438# 0.06318f
C53 m2_n7_n8438# m2_n7_n7696# 0.20728f
C54 m2_n7_n276# Sh2b 0.09596f
C55 a_484_n9212# Sh1 0
C56 Sh4 a_484_n9212# 0.00884f
C57 Sh2b A2 0
C58 Sh4 m2_n7_n7696# 0
C59 Sh1 m2_n7_n7696# 0.03766f
C60 Sh8 a_484_n4760# 0
C61 OUT5 a_484_n2534# 0
C62 a_2735_n8622# m2_n7_n9180# 0
C63 a_484_n7728# a_484_n9954# 0.17894f
C64 Sh4b OUT4 0
C65 Sh4 a_484_n1792# 0.01512f
C66 A0 Sh2b 0
C67 Sh1 A10 0.01558f
C68 a_2735_n9355# a_2735_n8622# 1.02656f
C69 a_2735_n8622# OUT13 0.00948f
C70 Sh8 OUT15 0.0166f
C71 a_484_n3276# a_484_n308# 0.02542f
C72 m2_n7_n1018# Sh1 0.02035f
C73 OUT3 OUT2 0.01035f
C74 Sh4 m2_n7_n1018# 0
C75 A15 Sh1 0.00978f
C76 a_484_n10696# m2_n7_n9180# 0.03524f
C77 Sh8b OUT9 0.01034f
C78 a_1337_n9945# a_484_n7728# 0.01186f
C79 m2_n7_n9922# m2_n7_n8438# 0.03117f
C80 A9 m2_n7_n5470# 0
C81 a_484_n9212# a_2735_n10830# 0.00393f
C82 Sh4 OUT10 0
C83 Sh2b a_484_434# 0.01146f
C84 a_2735_n8622# m2_n7_n10664# 0
C85 m2_n7_n9922# Sh1 0.02035f
C86 Sh4 m2_n7_n9922# 0
C87 a_2735_n7880# a_2735_n8622# 1.36213f
C88 a_2735_n8622# OUT12 0.05488f
C89 m2_n7_n4728# m2_n7_n6954# 0
C90 a_2735_n9355# a_484_n10696# 0
C91 Sh8 a_484_n2534# 0
C92 Sh2b a_484_n9954# 0.01174f
C93 A4 Sh1 0.01558f
C94 m2_n7_n4728# a_484_n5502# 0.03474f
C95 m2_n7_n1760# a_484_n3276# 0.03524f
C96 Sh2b m2_n7_n4728# 0.09596f
C97 A13 m2_n7_n9180# 0.14389f
C98 Sh8 OUT8 0.01726f
C99 A3 m2_n7_n2502# 0.04379f
C100 Sh2 a_484_n10696# 0.02188f
C101 Sh4b a_2735_n8622# 0.0114f
C102 Sh2b m2_n7_n2502# 0.06873f
C103 m2_n7_n10664# a_484_n10696# 0.10709f
C104 A7 Sh1b 0.05457f
C105 a_2735_n7880# a_484_n10696# 0
C106 A5 A4 0.04228f
C107 A11 m2_n7_n6954# 0
C108 m2_n7_n4728# a_484_n6244# 0.03524f
C109 Sh4 OUT4 0
C110 a_2735_n9355# m2_n7_n9180# 0
C111 Sh2b A6 0
C112 A12 m2_n7_n9180# 0.04379f
C113 A13 A12 0.04228f
C114 Sh8 a_484_n9212# 0
C115 a_2735_n8622# OUT14 0
C116 Sh2b a_1337_n9945# 0
C117 m2_n7_n9922# a_2735_n10830# 0
C118 Sh8b OUT2 0.01034f
C119 Sh2 m2_n7_n9180# 0.01946f
C120 Sh4b a_484_n10696# 0.01427f
C121 Sh2b m2_n7_n3244# 0.09596f
C122 Sh4b OUT7 0
C123 m2_n7_n10664# m2_n7_n9180# 0.02547f
C124 a_484_n6986# a_484_n9954# 0.02473f
C125 A9 m2_n7_n6212# 0.14389f
C126 Sh2b m2_n7_466# 0.06833f
C127 a_2735_n9355# OUT13 0.05487f
C128 OUT0 Sh8b 0.01034f
C129 OUT11 a_484_n5502# 0
C130 Sh2 A12 0
C131 a_2735_n9355# Sh2 0
C132 Sh8b a_484_434# 0
C133 OUT5 OUT4 0.01035f
C134 m2_n7_n1760# m2_n7_n3986# 0
C135 Sh1b m2_n7_n9180# 0.0106f
C136 Sh4b m2_n7_n9180# 0
C137 A14 m2_n7_n9180# 0.00301f
C138 a_2735_n9355# m2_n7_n10664# 0
C139 Sh1b A13 0.05457f
C140 A14 A13 0.04228f
C141 a_2735_n7880# a_2735_n9355# 0.04264f
C142 a_2735_n7880# OUT13 0.00134f
C143 A9 A8 0.04228f
C144 a_484_n2534# a_484_n308# 0.16607f
C145 OUT13 OUT12 0.01035f
C146 Sh2 m2_n7_n10664# 0.00893f
C147 a_484_n8470# a_484_n9954# 0.04848f
C148 a_2735_n8622# m2_n7_n8438# 0
C149 Sh8b a_484_n9954# 0
C150 Sh8 OUT10 0.01727f
C151 a_1337_n9945# a_484_n6986# 0.03526f
C152 a_2735_n7880# Sh2 0
C153 OUT11 a_484_n6244# 0
C154 Sh4 a_2735_n8622# 0.02312f
C155 m2_n7_n4728# m2_n7_n5470# 0.20728f
C156 a_2735_n9355# Sh1b 0
C157 a_2735_n9355# Sh4b 0.01142f
C158 Sh4b A12 0
C159 Sh1b A12 0.05457f
C160 Sh4b OUT13 0
C161 A7 Sh1 0.01558f
C162 a_2735_n7880# OUT12 0.00992f
C163 m2_n7_n4728# a_484_n3276# 0
C164 OUT9 OUT8 0.01035f
C165 a_484_n308# a_484_n1050# 1.44425f
C166 Sh2 Sh4b 0.29214f
C167 Sh2 A14 0
C168 m2_n7_n1760# a_484_n2534# 0.03474f
C169 a_484_n3276# m2_n7_n2502# 0.06318f
C170 m2_n7_n10664# Sh1b 0.01011f
C171 Sh4b m2_n7_n10664# 0
C172 A14 m2_n7_n10664# 0.04379f
C173 a_1337_n9945# a_484_n8470# 0.11079f
C174 a_2735_n7880# Sh1b 0
C175 a_2735_n7880# Sh4b 0.01206f
C176 Sh8b a_1337_n9945# 0.01788f
C177 m2_n7_n4728# a_484_n4018# 0
C178 a_2735_n9355# OUT14 0.00926f
C179 Sh4b OUT12 0
C180 Sh4 a_484_n10696# 0.00843f
C181 OUT14 OUT13 0.01047f
C182 A6 a_484_n3276# 0
C183 Sh4 OUT7 0
C184 Sh8 OUT4 0.01727f
C185 m2_n7_n5470# m2_n7_n3244# 0
C186 a_484_n308# a_484_n1792# 0.0616f
C187 m2_n7_n2502# a_484_n4018# 0.03526f
C188 a_484_n3276# m2_n7_n3244# 0.11174f
C189 Sh8b OUT6 0.01034f
C190 m2_n7_n1760# a_484_n1050# 0
C191 A14 Sh1b 0.05457f
C192 Sh4b A14 0
C193 a_2735_n8622# a_2735_n10830# 0.06249f
C194 A1 Sh1b 0.05457f
C195 a_2735_n7880# OUT14 0.00134f
C196 OUT11 Sh8b 0.01034f
C197 m2_n7_n4728# a_484_n4760# 0.10709f
C198 A6 a_484_n4018# 0
C199 m2_n7_n8438# m2_n7_n9180# 0.45905f
C200 m2_n7_n8438# A13 0
C201 OUT6 a_484_n3276# 0
C202 m2_n7_n276# a_484_n1050# 0.03545f
C203 Sh4 m2_n7_n9180# 0
C204 Sh1 m2_n7_n9180# 0.03766f
C205 A9 A10 0.04228f
C206 m2_n7_n3244# a_484_n4018# 0.03545f
C207 a_484_n308# m2_n7_n1018# 0.00146f
C208 Sh1 A13 0.01558f
C209 m2_n7_n1760# a_484_n1792# 0.10709f
C210 A2 a_484_n1050# 0
C211 Sh4b OUT14 0
C212 m2_n7_n4728# m2_n7_n6212# 0.02712f
C213 m2_n7_n4728# m2_n7_n3986# 0.45905f
C214 a_2735_n9355# m2_n7_n8438# 0
C215 m2_n7_n8438# A12 0.12891f
C216 a_484_n10696# a_2735_n10830# 0.07838f
C217 m2_n7_n276# a_484_n1792# 0.03524f
C218 a_2735_n9355# Sh1 0
C219 a_2735_n9355# Sh4 0.02328f
C220 Sh1 A12 0.01558f
C221 Sh2 m2_n7_n8438# 0.0207f
C222 m2_n7_n3244# a_484_n4760# 0.03524f
C223 m2_n7_n2502# m2_n7_n3986# 0.03117f
C224 Sh4 OUT13 0
C225 OUT10 OUT9 0.01047f
C226 A4 a_484_n308# 0
C227 m2_n7_n1760# m2_n7_n1018# 0.45905f
C228 a_484_n2534# a_484_434# 0.03117f
C229 m2_n7_n6954# a_484_n7728# 0.08396f
C230 Sh8 a_2735_n8622# 0.00835f
C231 m2_n7_n4728# A8 0.00301f
C232 A6 m2_n7_n3986# 0.12891f
C233 m2_n7_n10664# Sh1 0.02108f
C234 Sh4 m2_n7_n10664# 0
C235 a_484_n7728# a_484_n5502# 0.06976f
C236 a_2735_n7880# Sh4 0.02322f
C237 a_2735_n7880# Sh1 0
C238 Sh2b a_484_n7728# 0.01057f
C239 m2_n7_n276# m2_n7_n1018# 0.20728f
C240 Sh4 OUT12 0
C241 m2_n7_n3244# m2_n7_n3986# 0.20728f
C242 m2_n7_n4728# a_484_n2534# 0
C243 OUT4 a_484_n308# 0
C244 a_1337_n9945# OUT15 0.00907f
C245 A2 m2_n7_n1018# 0.12891f
C246 m2_n7_n8438# Sh1b 0.01328f
C247 Sh4b m2_n7_n8438# 0.00101f
C248 a_484_434# a_484_n1050# 0.04848f
C249 A4 m2_n7_n1760# 0.00301f
C250 a_484_n2534# m2_n7_n2502# 0.17613f
C251 Sh4b Sh4 1.08652f
C252 Sh1b Sh1 1.08645f
C253 A14 Sh1 0.01558f
C254 a_484_n7728# a_484_n6244# 0.0616f
C255 A1 Sh1 0.01558f
C256 Sh8 a_484_n10696# 0
C257 Sh8 OUT7 0.01726f
C258 a_2735_n9355# a_2735_n10830# 0.06314f
C259 A6 a_484_n2534# 0
C260 a_484_434# a_484_n1792# 0.06976f
C261 Sh2 a_2735_n10830# 0
C262 A5 Sh1b 0.05457f
C263 a_484_n9212# a_484_n9954# 0.66545f
C264 a_484_n2534# m2_n7_n3244# 0
C265 m2_n7_n2502# a_484_n1050# 0.00785f
C266 m2_n7_n6954# a_484_n5502# 0
C267 m2_n7_n10664# a_2735_n10830# 0
C268 Sh4 OUT14 0
C269 a_484_n7728# a_484_n6986# 1.79123f
C270 Sh2b m2_n7_n6954# 0.06873f
C271 a_2735_n7880# a_2735_n10830# 0.06221f
C272 Sh2b a_484_n5502# 0.01146f
C273 OUT6 a_484_n2534# 0
C274 a_484_434# m2_n7_n1018# 0
C275 Sh4b OUT5 0
C276 m2_n7_n3244# a_484_n1050# 0
C277 m2_n7_n2502# a_484_n1792# 0.0105f
C278 a_2735_n10830# Sh1b 0
C279 Sh4b a_2735_n10830# 0.0103f
C280 m2_n7_n6954# a_484_n6244# 0.00146f
C281 a_484_n9212# a_1337_n9945# 0.01215f
C282 A11 m2_n7_n7696# 0.14389f
C283 a_2735_n9355# Sh8 0.00835f
C284 a_484_n7728# a_484_n8470# 0.12627f
C285 a_484_n6244# a_484_n5502# 1.12257f
C286 m2_n7_466# a_484_n1050# 0.03526f
C287 Sh8 OUT13 0.01726f
C288 Sh8b a_484_n7728# 0
C289 Sh2b a_484_n6244# 0.01289f
C290 A6 a_484_n1792# 0
C291 m2_n7_n9922# a_484_n9954# 0.19703f
C292 Sh4 m2_n7_n8438# 0
C293 m2_n7_n8438# Sh1 0.02035f
C294 m2_n7_n3244# a_484_n1792# 0
C295 m2_n7_n2502# m2_n7_n1018# 0.03117f
C296 m2_n7_n6954# a_484_n6986# 0.19703f
C297 A11 A10 0.04228f
C298 a_2735_n7880# Sh8 0.00835f
C299 Sh8 OUT12 0.01727f
C300 a_484_n6986# a_484_n5502# 0.04848f
C301 Sh2b a_484_n6986# 0.01174f
C302 A5 Sh1 0.01558f
C303 A4 m2_n7_n2502# 0.12891f
C304 m2_n7_n6954# a_484_n8470# 0.03526f
C305 a_1337_n9945# m2_n7_n9922# 0
C306 m2_n7_466# m2_n7_n1018# 0.03117f
C307 a_484_n6986# a_484_n6244# 1.44425f
C308 m2_n7_n5470# m2_n7_n6954# 0.03117f
C309 a_484_n5502# a_484_n8470# 0.03117f
C310 Sh2b a_484_n8470# 0.01146f
C311 a_484_n7728# a_484_n4760# 0.02705f
C312 Sh8b a_484_n5502# 0
C313 m2_n7_n5470# a_484_n5502# 0.17613f
C314 Sh4 OUT5 0
C315 Sh8 OUT14 0.01727f
C316 Sh2b m2_n7_n5470# 0.06873f
C317 OUT11 OUT10 0.01035f
C318 A4 m2_n7_n3244# 0.04379f
C319 Sh8 OUT1 0.01726f
C320 a_484_n3276# a_484_n5502# 0.16607f
C321 Sh4 a_2735_n10830# 0.02218f
C322 a_2735_n10830# Sh1 0
C323 Sh2b a_484_n3276# 0.01289f
C324 Sh8b OUT3 0.01034f
C325 a_484_n6244# a_484_n8470# 0.16607f
C326 a_484_n7728# m2_n7_n6212# 0.03524f
C327 Sh8b a_484_n6244# 0
C328 Sh2 a_484_n308# 0.02742f
C329 m2_n7_n5470# a_484_n6244# 0.06318f
C330 a_484_n5502# a_484_n4018# 0.08718f
C331 Sh2b a_484_n4018# 0.01174f
C332 a_484_n3276# a_484_n6244# 0.02542f
C333 m2_n7_n6954# a_484_n4760# 0.00431f
C334 a_484_n6986# a_484_n8470# 0.08718f
C335 Sh8b a_484_n6986# 0
C336 m2_n7_n5470# a_484_n6986# 0.03526f
C337 a_484_n6244# a_484_n4018# 0.16447f
C338 a_484_n5502# a_484_n4760# 0.12971f
C339 a_2735_n8622# a_484_n9954# 0
C340 Sh2b a_484_n4760# 0.01057f
C341 Sh2 m2_n7_n1760# 0.01949f
C342 a_484_n308# Sh1b 0.00117f
C343 Sh4b a_484_n308# 0.10162f
C344 A1 a_484_n308# 0
C345 m2_n7_n6954# m2_n7_n6212# 0.20728f
C346 A7 m2_n7_n4728# 0.14389f
C347 A9 Sh1b 0.05457f
C348 m2_n7_n276# Sh2 0.01946f
C349 a_484_n5502# m2_n7_n6212# 0
C350 Sh8b a_484_n8470# 0
C351 Sh4b OUT9 0
C352 Sh2b m2_n7_n6212# 0.09596f
C353 a_484_n6986# a_484_n4018# 0.02473f
C354 a_484_n5502# m2_n7_n3986# 0.03526f
C355 a_484_n6244# a_484_n4760# 0.09086f
C356 Sh2b m2_n7_n3986# 0.06873f
C357 Sh2 A2 0
C358 a_484_n10696# a_484_n9954# 0.35611f
C359 a_2735_n8622# a_1337_n9945# 0.04293f
C360 m2_n7_n1760# Sh1b 0.0106f
C361 Sh4b m2_n7_n1760# 0
C362 A7 A6 0.04228f
C363 Sh8b a_484_n3276# 0
C364 a_484_n9212# a_484_n7728# 0.08918f
C365 a_484_n7728# m2_n7_n7696# 0.10709f
C366 A0 Sh2 0
C367 a_484_n3276# m2_n7_n5470# 0.0024f
C368 a_484_n5502# A8 0
C369 a_484_n6244# m2_n7_n6212# 0.11174f
C370 a_484_n6986# a_484_n4760# 0.17894f
C371 Sh2b A8 0
C372 Sh8 OUT5 0.01726f
C373 m2_n7_n276# Sh1b 0.0106f
C374 m2_n7_n276# Sh4b 0
C375 m2_n7_n276# A1 0.14389f
C376 Sh8 a_2735_n10830# 0.00794f
C377 Sh8b a_484_n4018# 0
C378 Sh4b A2 0
C379 A2 Sh1b 0.05457f
C380 a_484_n2534# a_484_n5502# 0.03117f
C381 A2 A1 0.04228f
C382 a_484_n9954# m2_n7_n9180# 0.03545f
C383 m2_n7_n5470# a_484_n4018# 0.00785f
C384 Sh2b a_484_n2534# 0.01146f
C385 a_1337_n9945# a_484_n10696# 0
C386 a_484_n3276# a_484_n4018# 1.44425f
C387 a_484_n6986# m2_n7_n6212# 0.03545f
C388 A0 Sh4b 0
C389 A0 Sh1b 0.05491f
C390 Sh2 a_484_434# 0.01949f
C391 a_484_n4760# a_484_n8470# 0
C392 A0 A1 0.04228f
C393 Sh8b a_484_n4760# 0
C394 a_484_n308# Sh1 0
C395 OUT7 OUT6 0.01035f
C396 Sh4 a_484_n308# 0.0189f
C397 a_2735_n9355# a_484_n9954# 0
C398 m2_n7_n6954# m2_n7_n7696# 0.45905f
C399 m2_n7_n5470# a_484_n4760# 0.0105f
C400 Sh2b a_484_n1050# 0.01174f
C401 m2_n7_n9922# a_484_n7728# 0.00431f
C402 a_484_n3276# a_484_n4760# 0.0616f
C403 Sh2 a_484_n9954# 0.02332f
C404 a_484_n5502# m2_n7_n7696# 0
C405 a_1337_n9945# m2_n7_n9180# 0
C406 Sh2b a_484_n9212# 0.01289f
C407 Sh2b m2_n7_n7696# 0.09596f
C408 Sh2 m2_n7_n4728# 0.01949f
C409 A9 Sh1 0.01558f
C410 Sh4 OUT9 0
C411 m2_n7_n10664# a_484_n9954# 0
C412 a_2735_n7880# a_484_n9954# 0
C413 m2_n7_n5470# m2_n7_n6212# 0.45905f
C414 Sh2 m2_n7_n2502# 0.0207f
C415 Sh4b a_484_434# 0.08485f
C416 OUT2 OUT1 0.01047f
C417 m2_n7_n6954# A10 0.12891f
C418 m2_n7_n5470# m2_n7_n3986# 0.03117f
C419 a_484_n1792# a_484_n5502# 0
C420 OUT15 a_484_n8470# 0
C421 a_484_n4760# a_484_n4018# 1.79123f
C422 Sh2b a_484_n1792# 0.01057f
C423 Sh8b OUT15 0.00991f
C424 m2_n7_n1760# Sh1 0.03766f
C425 Sh4 m2_n7_n1760# 0
C426 a_484_n3276# m2_n7_n3986# 0.00146f
C427 a_484_n9212# a_484_n6244# 0.02542f
C428 a_2735_n9355# a_1337_n9945# 0.69668f
C429 a_484_n5502# A10 0
C430 A11 A12 0.04228f
C431 a_484_n6244# m2_n7_n7696# 0
C432 Sh2b A10 0
C433 Sh2 A6 0
C434 a_484_n9954# Sh1b 0
C435 Sh4b a_484_n9954# 0.02028f
C436 A3 m2_n7_n1018# 0
C437 OUT0 OUT1 0.01035f
C438 A14 a_484_n9954# 0
C439 Sh2 a_1337_n9945# 0
C440 m2_n7_n4728# Sh1b 0.0106f
C441 Sh4b m2_n7_n4728# 0
C442 m2_n7_n276# Sh4 0
C443 m2_n7_n276# Sh1 0.03766f
C444 m2_n7_n5470# A8 0.12891f
C445 a_484_n4018# m2_n7_n6212# 0
C446 Sh2 m2_n7_n3244# 0.01946f
C447 m2_n7_n3986# a_484_n4018# 0.19703f
C448 Sh2b m2_n7_n1018# 0.06873f
C449 a_1337_n9945# m2_n7_n10664# 0
C450 A2 Sh1 0.01558f
C451 a_2735_n7880# a_1337_n9945# 0.04256f
C452 a_484_n3276# A8 0
C453 m2_n7_n2502# Sh1b 0.01328f
C454 Sh4b m2_n7_n2502# 0.00101f
C455 Sh8b a_484_n2534# 0
C456 a_484_n9212# a_484_n6986# 0.16447f
C457 Sh2 m2_n7_466# 0.0207f
C458 a_484_n6986# m2_n7_n7696# 0
C459 a_484_n6244# A10 0
C460 a_484_n5502# OUT10 0
C461 Sh2b m2_n7_n9922# 0.04224f
C462 Sh8b OUT8 0.01034f
C463 Sh4b A6 0
C464 A6 Sh1b 0.05457f
C465 A4 A3 0.04228f
C466 a_484_n3276# a_484_n2534# 1.12257f
C467 A0 Sh1 0.01558f
C468 a_484_n4018# A8 0
C469 a_484_n4760# m2_n7_n6212# 0
C470 m2_n7_n3986# a_484_n4760# 0.08396f
C471 a_1337_n9945# Sh1b 0
C472 A11 Sh1b 0.05457f
C473 Sh4b a_1337_n9945# 0.01156f
C474 a_2735_n7880# OUT11 0.05555f
C475 a_484_n3276# OUT8 0
C476 Sh4b m2_n7_n3244# 0
C477 m2_n7_n3244# Sh1b 0.0106f
C478 Sh2b A4 0
C479 a_484_n6986# A10 0
C480 OUT11 OUT12 0.01047f
C481 a_484_n6244# OUT10 0
C482 a_484_n2534# a_484_n4018# 0.04848f
C483 a_484_n9212# a_484_n8470# 1.00551f
C484 a_484_n8470# m2_n7_n7696# 0.03474f
C485 Sh8b a_484_n9212# 0
C486 Sh4b m2_n7_466# 0.00101f
C487 m2_n7_466# Sh1b 0.01328f
C488 Sh4b OUT6 0
C489 A1 m2_n7_466# 0
C490 a_484_n3276# a_484_n1050# 0.16447f
C491 a_484_n4760# A8 0
C492 OUT11 Sh4b 0
C493 a_1337_n9945# OUT14 0.05488f
C494 Sh4 a_484_434# 0.0262f
C495 a_2735_n8622# a_484_n7728# 0.00968f
C496 a_484_n2534# a_484_n4760# 0.06976f
C497 a_484_n1050# a_484_n4018# 0.02473f
C498 m2_n7_n8438# a_484_n9954# 0.03526f
C499 Sh8 OUT9 0.01726f
C500 A8 m2_n7_n6212# 0.04379f
C501 a_484_n3276# a_484_n1792# 0.09086f
C502 OUT4 OUT3 0.01047f
C503 Sh4 a_484_n9954# 0.00884f
C504 Sh4 m2_n7_n4728# 0
C505 m2_n7_n4728# Sh1 0.03766f
C506 m2_n7_n2502# Sh1 0.02035f
C507 a_484_n2534# m2_n7_n3986# 0
C508 Sh4 m2_n7_n2502# 0
C509 a_484_n1792# a_484_n4018# 0.17894f
C510 a_484_n10696# a_484_n7728# 0.02705f
C511 Sh8b OUT10 0.01034f
C512 m2_n7_n9922# a_484_n8470# 0
C513 A11 m2_n7_n8438# 0.04379f
C514 A6 Sh1 0.01558f
C515 A5 m2_n7_n2502# 0
C516 a_1337_n9945# Sh1 0
C517 A11 Sh1 0.01558f
C518 Sh4 a_1337_n9945# 0.02366f
C519 Sh4 m2_n7_n3244# 0
C520 m2_n7_n3244# Sh1 0.03766f
C521 a_484_n1792# a_484_n4760# 0.02705f
C522 a_2735_n8622# a_484_n5502# 0.03526f
C523 A6 A5 0.04228f
C524 a_484_n7728# m2_n7_n9180# 0
C525 m2_n7_n7696# m2_n7_n6212# 0.02712f
C526 a_2735_n10830# a_484_n9954# 0.01085f
C527 Sh4 m2_n7_466# 0
C528 m2_n7_466# Sh1 0.01937f
C529 a_484_n4760# A10 0
C530 Sh4 OUT6 0
C531 A5 m2_n7_n3244# 0.14389f
C532 Sh8 OUT2 0.01727f
C533 a_484_n9212# OUT15 0
C534 OUT11 Sh4 0
C535 Sh8b OUT4 0.01034f
C536 a_484_n1792# m2_n7_n3986# 0.00431f
C537 a_2735_n8622# a_484_n6244# 0.02655f
C538 a_2735_n9355# a_484_n7728# 0.00126f
C539 OUT0 Sh8 0.0164f
C540 a_484_n7728# A12 0
C541 A10 m2_n7_n6212# 0.00301f
C542 Sh2b a_484_n10696# 0.01009f
C543 a_484_n2534# a_484_n1050# 0.08718f
C544 Sh2 a_484_n7728# 0.06608f
C545 a_1337_n9945# a_2735_n10830# 0.38352f
C546 m2_n7_n1760# a_484_n308# 0
C547 a_2735_n8622# a_484_n6986# 0.00224f
C548 a_2735_n7880# a_484_n7728# 0.08445f
C549 OUT6 OUT5 0.01047f
C550 Sh8 a_484_n9954# 0
C551 m2_n7_n276# a_484_n308# 0.11174f
C552 a_484_n2534# a_484_n1792# 0.12971f
C553 Sh2b m2_n7_n9180# 0.09543f
C554 A2 a_484_n308# 0
C555 Sh4b a_484_n7728# 0.07176f
C556 A14 a_484_n7728# 0
C557 a_2735_n8622# a_484_n8470# 0.13363f
C558 a_484_n9212# m2_n7_n7696# 0.03524f
C559 Sh8b a_2735_n8622# 0.01983f
C560 a_484_n2534# m2_n7_n1018# 0.03526f
C561 Sh2 m2_n7_n6954# 0.02076f
C562 a_484_n1792# a_484_n1050# 1.79123f
C563 a_2735_n9355# Sh2b 0
C564 Sh2b A12 0
C565 m2_n7_n276# m2_n7_n1760# 0.02712f
C566 Sh8 a_1337_n9945# 0.00835f
C567 Sh2 a_484_n5502# 0.02023f
C568 Sh2 Sh2b 1.08645f
C569 a_2735_n7880# m2_n7_n6954# 0
C570 A7 m2_n7_n5470# 0.04379f
C571 A2 m2_n7_n1760# 0.04379f
C572 Sh2b m2_n7_n10664# 0.01973f
C573 A10 m2_n7_n7696# 0.04379f
C574 a_2735_n7880# a_484_n5502# 0.04991f
C575 a_2735_n7880# Sh2b 0
C576 Sh8 OUT6 0.01727f
C577 a_2735_n9355# a_484_n6244# 0.03529f
C578 m2_n7_n1018# a_484_n1050# 0.19703f
C579 a_484_n10696# a_484_n8470# 0.06581f
C580 a_484_n6986# m2_n7_n9180# 0
C581 a_484_n6244# A12 0
C582 Sh8b a_484_n10696# 0
C583 A4 a_484_n2534# 0
C584 OUT11 Sh8 0.01726f
C585 Sh8b OUT7 0.01034f
C586 m2_n7_n276# A2 0.00301f
C587 a_484_n308# a_484_434# 1.12257f
C588 Sh4b m2_n7_n6954# 0
C589 m2_n7_n6954# Sh1b 0.01328f
C590 Sh2 a_484_n6244# 0.02742f
C591 A3 Sh1b 0.05457f
C592 Sh4b a_484_n5502# 0.08528f
C593 OUT7 a_484_n3276# 0
C594 Sh2b A14 0
C595 a_2735_n7880# a_484_n6244# 0.00492f
C596 A0 m2_n7_n276# 0.04379f
C597 m2_n7_n9922# m2_n7_n7696# 0
C598 a_484_n9212# m2_n7_n9922# 0.00146f
C599 a_2735_n9355# a_484_n6986# 0.01606f
C600 m2_n7_n1018# a_484_n1792# 0.08396f
C601 a_484_n6986# A12 0
C602 a_484_n6244# OUT12 0
C603 A4 a_484_n1050# 0
C604 a_484_n8470# m2_n7_n9180# 0
C605 m2_n7_n8438# a_484_n7728# 0.0105f
C606 Sh2 a_484_n6986# 0.03861f
C607 m2_n7_n1760# a_484_434# 0
C608 a_484_n308# m2_n7_n2502# 0.0024f
C609 a_484_n6244# Sh1b 0.00117f
C610 Sh4 a_484_n7728# 0.01525f
C611 Sh4b a_484_n6244# 0.10162f
C612 a_2735_n7880# a_484_n6986# 0.01172f
C613 A4 a_484_n1792# 0
C614 m2_n7_n276# a_484_434# 0
C615 a_2735_n9355# a_484_n8470# 0.10341f
C616 a_484_n8470# A12 0
C617 a_484_n8470# OUT13 0
C618 a_2735_n9355# Sh8b 0.01871f
C619 Sh8b OUT13 0.01034f
C620 a_2735_n8622# OUT15 0
C621 A7 m2_n7_n3986# 0
C622 A2 a_484_434# 0
C623 A15 m2_n7_n9922# 0
C624 Sh2 a_484_n8470# 0.02023f
C625 a_484_n6986# Sh1b 0
C626 Sh4b a_484_n6986# 0.08402f
C627 m2_n7_n1760# m2_n7_n2502# 0.20728f
C628 Sh2 m2_n7_n5470# 0.0207f
C629 m2_n7_n10664# a_484_n8470# 0
C630 m2_n7_466# a_484_n308# 0.06318f
C631 a_2735_n7880# a_484_n8470# 0
C632 a_2735_n7880# Sh8b 0.02148f
C633 A0 a_484_434# 0
C634 m2_n7_n6954# m2_n7_n8438# 0.03117f
C635 Sh2 a_484_n3276# 0.02742f
C636 Sh8b OUT12 0.01034f
C637 A7 A8 0.04228f
C638 m2_n7_n276# m2_n7_n2502# 0
C639 Sh4 m2_n7_n6954# 0
C640 m2_n7_n6954# Sh1 0.02035f
C641 A3 Sh1 0.01558f
C642 a_484_n7728# a_2735_n10830# 0.03529f
C643 Sh2b m2_n7_n8438# 0.06873f
C644 m2_n7_n1760# m2_n7_n3244# 0.02712f
C645 Sh4b a_484_n8470# 0.05879f
C646 A14 a_484_n8470# 0
C647 Sh4 a_484_n5502# 0.0266f
C648 Sh2 a_484_n4018# 0.03861f
C649 Sh2b Sh1 0.73606f
C650 m2_n7_n5470# Sh1b 0.01328f
C651 Sh4b m2_n7_n5470# 0.00101f
C652 a_484_n3276# Sh1b 0.00117f
C653 Sh4b a_484_n3276# 0.10162f
C654 m2_n7_n8438# a_484_n6244# 0.0024f
C655 m2_n7_n276# m2_n7_466# 0.45905f
C656 a_484_n6244# Sh1 0
C657 OUT14 a_484_n8470# 0
C658 Sh4 a_484_n6244# 0.01903f
C659 Sh2 a_484_n4760# 0.06608f
C660 OUT7 a_484_n2534# 0
C661 Sh8b OUT14 0.01034f
C662 a_484_n9212# a_2735_n8622# 0
C663 Sh8b OUT1 0.01034f
C664 a_484_n4018# Sh1b 0
C665 Sh4b a_484_n4018# 0.08402f
C666 OUT7 OUT8 0.01048f
C667 a_2735_n7880# a_484_n4760# 0.03529f
C668 m2_n7_n8438# a_484_n6986# 0.00785f
C669 Sh8 a_484_n7728# 0
C670 Sh2 m2_n7_n6212# 0.01946f
C671 A0 m2_n7_466# 0.12891f
C672 a_2735_n9355# OUT15 0
C673 Sh4 a_484_n6986# 0.0167f
C674 Sh2 m2_n7_n3986# 0.02076f
C675 Sh2b a_2735_n10830# 0
C676 Sh4b a_484_n4760# 0.07228f
C677 a_484_n9212# a_484_n10696# 0.06144f
C678 a_2735_n7880# OUT15 0.00134f
C679 m2_n7_n8438# a_484_n8470# 0.17613f
C680 Sh2 A8 0
C681 a_2735_n8622# m2_n7_n9922# 0
C682 Sh4 a_484_n8470# 0.02135f
C683 Sh4b m2_n7_n6212# 0
C684 Sh1b m2_n7_n6212# 0.0106f
C685 A6 m2_n7_n4728# 0.04379f
C686 m2_n7_n3986# Sh1b 0.01328f
C687 Sh8b Sh4 0.13147f
C688 Sh4b m2_n7_n3986# 0
C689 m2_n7_466# a_484_434# 0.17613f
C690 a_1337_n9945# a_484_n9954# 0.07673f
C691 m2_n7_n5470# Sh1 0.02035f
C692 Sh2 a_484_n2534# 0.02023f
C693 a_484_n9212# m2_n7_n9180# 0.11174f
C694 Sh4 m2_n7_n5470# 0
C695 a_484_n9212# A13 0
C696 m2_n7_n7696# m2_n7_n9180# 0.02712f
C697 Sh4b OUT15 0
C698 m2_n7_n4728# m2_n7_n3244# 0.02712f
C699 a_484_n3276# Sh1 0
C700 Sh4 a_484_n3276# 0.01896f
C701 Sh8 a_484_n5502# 0
C702 Sh1b A8 0.05457f
C703 m2_n7_n3244# m2_n7_n2502# 0.45905f
C704 Sh4b A8 0
C705 A5 a_484_n3276# 0
C706 m2_n7_n9922# a_484_n10696# 0.08366f
C707 a_2735_n9355# a_484_n9212# 0.07634f
C708 Sh4 a_484_n4018# 0.01663f
C709 Sh2 a_484_n1050# 0.03861f
C710 m2_n7_n7696# A12 0.00301f
C711 A6 m2_n7_n3244# 0.00301f
C712 Sh8 OUT3 0.01726f
C713 OUT14 OUT15 0.01035f
C714 Sh4b a_484_n2534# 0.08528f
C715 Sh2 a_484_n9212# 0.02311f
C716 Sh2 m2_n7_n7696# 0.01949f
C717 Sh8 a_484_n6244# 0
C718 Sh8b OUT5 0.01034f
C719 a_2735_n10830# a_484_n8470# 0.06351f
C720 Sh4b OUT8 0
C721 a_484_n9212# m2_n7_n10664# 0
C722 Sh8b a_2735_n10830# 0.01322f
C723 a_2735_n7880# a_484_n9212# 0
C724 a_2735_n7880# m2_n7_n7696# 0
C725 Sh2 a_484_n1792# 0.06608f
C726 Sh4 a_484_n4760# 0.01518f
C727 m2_n7_n9922# m2_n7_n9180# 0.20379f
C728 m2_n7_n9922# A13 0.04379f
C729 a_484_n1050# Sh1b 0
C730 Sh4b a_484_n1050# 0.08402f
C731 a_484_n10696# GND 0.69733f
C732 m2_n7_n8438# GND 0.62155f
C733 a_484_n5502# GND 0.65831f
C734 a_484_n6244# GND 0.77284f
C735 a_484_n6986# GND 0.84221f
C736 a_484_n7728# GND 3.77629f
C737 m2_n7_n6954# GND 0.61083f
C738 m2_n7_n5470# GND 0.62143f
C739 A9 GND 0.42559f
C740 a_484_n2534# GND 0.66183f
C741 a_484_n3276# GND 0.77146f
C742 a_484_n4018# GND 0.84065f
C743 a_484_n4760# GND 3.78521f
C744 m2_n7_n3986# GND 0.61091f
C745 m2_n7_n2502# GND 0.62178f
C746 m2_n7_n3244# GND 1.82018f
C747 a_484_434# GND 1.22724f
C748 a_484_n308# GND 1.08505f
C749 a_484_n1050# GND 1.04118f
C750 a_484_n1792# GND 3.80923f
C751 m2_n7_n1018# GND 0.61524f
C752 m2_n7_466# GND 0.93739f
C753 A15 GND 0.35423f
C754 OUT15 GND 0.17433f
C755 m2_n7_n10664# GND 0.6389f
C756 A14 GND 0.4367f
C757 OUT14 GND 0.15622f
C758 A13 GND 0.42559f
C759 OUT13 GND 0.15516f
C760 m2_n7_n9180# GND 1.82594f
C761 A12 GND 0.43285f
C762 OUT12 GND 0.15317f
C763 A11 GND 0.42559f
C764 OUT11 GND 0.15053f
C765 m2_n7_n7696# GND 1.82156f
C766 A10 GND 0.43335f
C767 OUT10 GND 0.14746f
C768 OUT9 GND 0.14408f
C769 m2_n7_n6212# GND 1.82018f
C770 A8 GND 0.43285f
C771 OUT8 GND 0.13894f
C772 A7 GND 0.42559f
C773 OUT7 GND 0.19434f
C774 m2_n7_n4728# GND 1.82166f
C775 A6 GND 0.43335f
C776 OUT6 GND 0.19404f
C777 A5 GND 0.42559f
C778 OUT5 GND 0.19412f
C779 A4 GND 0.43285f
C780 OUT4 GND 0.19357f
C781 A3 GND 0.42559f
C782 OUT3 GND 0.19302f
C783 m2_n7_n1760# GND 1.8216f
C784 A2 GND 0.43351f
C785 OUT2 GND 0.19326f
C786 A1 GND 0.42559f
C787 OUT1 GND 0.19574f
C788 m2_n7_n276# GND 1.84826f
C789 A0 GND 0.47628f
C790 OUT0 GND 0.22444f
C791 Sh8 GND 9.37549f
C792 Sh8b GND 8.90568f
C793 Sh4 GND 9.40666f
C794 Sh4b GND 8.58078f
C795 Sh2 GND 9.09978f
C796 Sh2b GND 8.07676f
C797 Sh1 GND 8.53461f
C798 Sh1b GND 8.69758f
C799 a_2735_n7147.t1 GND 0.01564f
C800 a_2735_n7147.t2 GND 0.81291f
C801 a_2735_n7147.n0 GND 1.15642f
C802 a_2735_n7147.t0 GND 0.01502f
C803 a_2735_n6735.t2 GND 0.03332f
C804 a_2735_n6735.t3 GND 0.12136f
C805 a_2735_n6735.t1 GND 1.63456f
C806 a_2735_n6735.n0 GND 3.93677f
C807 a_2735_n6735.n1 GND 0.14199f
C808 a_2735_n6735.t0 GND 0.03201f
C809 a_2735_n506.t2 GND 0.03049f
C810 a_2735_n506.t3 GND 0.10417f
C811 a_2735_n506.t1 GND 1.30263f
C812 a_2735_n506.n0 GND 3.69303f
C813 a_2735_n506.n1 GND 0.14039f
C814 a_2735_n506.t0 GND 0.02929f
C815 a_2735_227.t2 GND 0.01459f
C816 a_2735_227.t3 GND 0.05089f
C817 a_2735_227.t1 GND 0.53398f
C818 a_2735_227.n0 GND 1.81397f
C819 a_2735_227.n1 GND 0.07256f
C820 a_2735_227.t0 GND 0.01402f
C821 a_2735_n8951.t2 GND 0.04286f
C822 a_2735_n8951.t3 GND 0.16756f
C823 a_2735_n8951.t1 GND 2.86522f
C824 a_2735_n8951.n0 GND 4.63822f
C825 a_2735_n8951.n1 GND 0.14497f
C826 a_2735_n8951.t0 GND 0.04117f
C827 a_2735_n9685.t2 GND 0.04541f
C828 a_2735_n9685.t3 GND 0.19197f
C829 a_2735_n9685.t1 GND 3.2997f
C830 a_2735_n9685.n0 GND 4.77556f
C831 a_2735_n9685.n1 GND 0.14374f
C832 a_2735_n9685.t0 GND 0.04362f
C833 a_2735_n5672.t1 GND 0.0151f
C834 a_2735_n5672.t2 GND 0.99457f
C835 a_2735_n5672.n0 GND 1.37582f
C836 a_2735_n5672.t0 GND 0.01451f
C837 a_2735_n6405.t1 GND 0.03074f
C838 a_2735_n6405.t2 GND 1.80288f
C839 a_2735_n6405.n0 GND 2.53685f
C840 a_2735_n6405.t0 GND 0.02953f
C841 a_2735_n7476.t2 GND 0.03682f
C842 a_2735_n7476.t3 GND 0.13319f
C843 a_2735_n7476.t1 GND 2.02161f
C844 a_2735_n7476.n0 GND 4.22763f
C845 a_2735_n7476.n1 GND 0.14538f
C846 a_2735_n7476.t0 GND 0.03536f
C847 a_2735_n4931.t2 GND 0.02319f
C848 a_2735_n4931.t3 GND 0.09943f
C849 a_2735_n4931.t1 GND 1.82257f
C850 a_2735_n4931.n0 GND 2.36343f
C851 a_2735_n4931.n1 GND 0.06911f
C852 a_2735_n4931.t0 GND 0.02227f
C853 a_2735_n8210.t2 GND 0.04017f
C854 a_2735_n8210.t3 GND 0.15626f
C855 a_2735_n8210.t1 GND 2.44282f
C856 a_2735_n8210.n0 GND 4.47629f
C857 a_2735_n8210.n1 GND 0.14587f
C858 a_2735_n8210.t0 GND 0.03858f
C859 a_2735_n10830# GND 0.80496f
C860 m2_n7_n9922# GND 0.54157f
C861 a_2735_n7880# GND 0.64591f
C862 a_484_n9954# GND 0.47392f
C863 a_484_n9212# GND 0.52736f
C864 a_484_n8470# GND 0.58261f
C865 a_2735_n8622# GND 0.58869f
C866 a_2735_n9355# GND 0.59325f
C867 a_1337_n9945# GND 0.58753f
.ends

X0 OUT1 OUT2 OUT3 OUT4 OUT5 OUT6 OUT7 OUT8 OUT9 OUT10 OUT11 OUT12 OUT0 OUT13 OUT14 OUT15 GND A1 A2
+ A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A0 A13 A14 A15 SHIFT


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
